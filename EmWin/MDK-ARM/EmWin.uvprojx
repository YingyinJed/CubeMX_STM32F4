# Keil uVision project EmWin.uvprojx, settings and files
target EmWin (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: EmWin +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\LCD;..\Touch;..\Delay;..\SRAM;..\MALLOC;..\STEMWIN\CMSIS\Include;..\STEMWIN\Demo;..\STEMWIN\STemWin\Config;..\STEMWIN\STemWin\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c fsmc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_crc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group LCD
    ../LCD/: ILI93xx.c
  group Touch
    ../Touch/: ctiic.c myiic.c 24cxx.c gt9147.c ft5206.c ott2001a.c touch.c
  group Delay
    ../Delay/: delay.c
  group SRAM
    ../SRAM/: sram.c
  group MALLOC
    ../MALLOC/: malloc.c
  group DSP_Lib
    ../STEMWIN/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../STEMWIN/CMSIS/Include/: arm_math.h
  group STemWin
    ../STEMWIN/STemWin/OS/: GUI_X.c
    ../STEMWIN/STemWin/Config/: GUIConf.c GUIDRV_Template.c GUI_X_Touch_Analog.c LCDConf_FlexColor_Template.c
  group STemLib
    ../STEMWIN/STemWin/Lib/: STemWin526_CM4_Keil.lib
  group STemDemo
    ../STEMWIN/Demo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_Touch.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
software components: CMSIS:CORE 4.3.0
